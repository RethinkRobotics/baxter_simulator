Commit message: Added IK Pick and Place sim demo

File: baxter_sim_examples/models/block/model.urdf (robot description, URDF)
Before this commit: robot block, 1 links, 0 joints
Links:
- link block: mass 1.0 -> 0.5; geometry collision box size=0.05 0.05 0.05; visual box size=0.05 0.05 0.05
